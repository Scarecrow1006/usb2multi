# Keil uVision project HID.uvproj, settings and files
target MCB2140 Board (ARM-ADS)
  device: LPC2148 Philips
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: HID
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group Source Code
    ./: usbcfg.h usbhw.c usbcore.c usbdesc.c usbuser.c hiduser.c demo.c
  group Documentation
    ./: Abstract.txt
